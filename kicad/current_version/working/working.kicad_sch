File: kicad/current_version/working/working.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: commiting after auto generation
Other:
- moved on the sheet: BB1, BB2, BB3
